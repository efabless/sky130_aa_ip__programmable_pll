** sch_path: xschem/TB_TOP_MUX_F7_sch_copy.sch
**.subckt TB_TOP_MUX_F7_sch_copy
V1 VSS GND 0
V4 VCTRL_IN VSS 0.6
V6 F_IN VSS pulse(0 1.8 1000n 100p 100p 50n 100n)
I4 VDD ITAIL 100u
V8 S1 VSS 0
V9 S2 VSS 0
V10 S3 VSS 0
V11 S4 VSS 0
V12 S6 VSS 0
V13 DN_INPUT VSS pulse(0 1.8 10n 100p 100p 500n 1000n)
V14 UP_INPUT VSS pulse(0 1.8 0 100p 100p 500n 1000n)
V16 S5 VSS 0
V17 D0 GND 0
V2 S7 VSS 0
V5 VDD VSS pwl(0 0 0.05US 0 0.050001US 1.8)
V35 D9 GND 0
V20 D3 GND 0
V22 D5 GND 1.8
V36 D10 GND 1.8
V7 D8 GND 0
V34 D7 GND 0
V21 D4 GND 0
V23 D6 GND 1.8
V25 D18 GND 0
V26 D15 GND 0
V31 D19 GND 0
V28 D16 GND 0
V27 D14 GND 0
V30 D12 GND 0
V32 D17 GND 0
V18 D2 GND 0
V19 D1 GND 1.8
V33 D13 GND 1.8
x1 D12 D0 VDD UP_INPUT D13 D1 DN_INPUT GND D14 D2 PRE_SCALAR UP_OUT D15 D3 F_IN DN_OUT D16 D4 ITAIL
+ DIV_OUT D5 S1 S6 D6 VCTRL_IN D7 S2 D8 S3 OUT D9 OUTB S4 VSS D10 S5 S7 OUT_USB D17 OUT_CORE D18 D19
+ sky130_aa_ip__programmable_pll
**** begin user architecture code


.ic v(x1.VCTRL_OBV)=0.25
*.option RSHUNT=1e18
**.option ABSTOL=1e-12
**.option VNTOL=1e-12
**.option CHGTOL=1e-14
**.option RELTOL=1e-5
.option gmin=1e-15
**.option trtol=1
**.OPTION ITL4=500
.control
save x1.UP  x1.DN  x1.UP1  x1.DN1  x1.VCTRL_OBV  x1.OUT  x1.OUTB  x1.OUTD  x1.IN_DIV  x1.OUT11
+  x1.UP_OUT  x1.pre_out  x1.OUTA1  x1.OUTA2  OUT1  OUT  OUTB  PRE_SCALAR  x1.UP_OUT  x1.OUT_D  x1.OUT01
+  x1.MUFTA2  x1.MUFTA  DN_OUT  UP_OUT  DIV_OUT  ITAIL  x1.ITAIL_SINK  x1.ITAIL_SRC  OUT_USB  OUT_CORE
+  v1#branch
tran 500n 100u

write TB_TOP_MUX_F7_sch.raw
.endc




* CACE gensim simulation file CACE{filename}
* Generated by CACE gensim, Efabless Corporation (c) 2024
* Find the powerup simulation of POR



*.lib /home/efabless/.volare/sky130A/libs.tech/combined/sky130.lib.spice tt
.lib /home/efabless/.volare/sky130A/libs.tech/ngspice/sky130.lib.spice tt

*.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sky130.lib.spice CACE{corner}

.option TEMP=27
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end
