v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Schematic redrawn by A.Reda (14/01/2025)} 1690 -170 0 0 0.5 0.5 {}
T {Divders Data and Muxes Selection Inputs} 30 -480 0 0 0.5 0.5 {}
T {External Inputs} 190 -890 0 0 0.5 0.5 {}
T {Bias Sources} 210 -1220 0 0 0.5 0.5 {}
T {Output Signals} 5670 -480 0 0 0.5 0.5 {}
T {Testing Nodes} 3270 -1310 0 0 0.5 0.5 {}
N 3720 -960 3720 -880 {lab=VDD}
N 3720 -760 3720 -700 {lab=VSS}
N 3870 -840 3980 -840 {lab=OUTA1}
N 3870 -810 3980 -810 {lab=OUTA2}
N 2960 -740 2960 -690 {lab=VSS}
N 2960 -960 2960 -880 {lab=VDD}
N 2980 -960 2980 -880 {lab=ITAIL_SINK}
N 3000 -960 3000 -880 {lab=ITAIL_SRC}
N 2760 -850 2810 -850 {lab=DN}
N 2760 -830 2810 -830 {lab=UP}
N 3020 -1370 3020 -1310 {lab=ITAIL}
N 3000 -1010 3000 -960 {lab=ITAIL_SRC}
N 2980 -1010 2980 -960 {lab=ITAIL_SINK}
N 3050 -1160 3110 -1160 {lab=VDD}
N 2870 -1160 2930 -1160 {lab=VSS}
N 3570 -810 3570 -750 {lab=VDD}
N 2520 -940 2520 -900 {lab=VDD}
N 2310 -830 2370 -830 {lab=FDIV}
N 2310 -850 2370 -850 {lab=FIN}
N 2670 -850 2700 -850 {lab=UP1}
N 2670 -830 2700 -830 {lab=DN1}
N 2520 -780 2520 -750 {lab=VSS}
N 3230 -680 3340 -680 {
lab=VSS}
N 3410 -700 3410 -680 {
lab=VSS}
N 3230 -830 3230 -740 {
lab=MUFTA}
N 3230 -830 3340 -830 {
lab=MUFTA}
N 3410 -830 3410 -820 {
lab=MUFTA}
N 3370 -790 3390 -790 {
lab=VSS}
N 3370 -790 3370 -680 {
lab=VSS}
N 3340 -680 3410 -680 {
lab=VSS}
N 3340 -830 3410 -830 {
lab=MUFTA}
N 3330 -680 3330 -650 {
lab=VSS}
N 3980 -810 3980 -360 {lab=OUTA2}
N 3890 -360 3980 -360 {lab=OUTA2}
N 3810 -490 3810 -430 {lab=VDD}
N 3800 -280 3800 -220 {lab=VSS}
N 3230 -500 3250 -500 {
lab=D6}
N 3230 -480 3270 -480 {
lab=D5}
N 3230 -460 3280 -460 {
lab=D4}
N 3230 -440 3290 -440 {
lab=D3}
N 3230 -420 3310 -420 {
lab=D2}
N 3230 -400 3340 -400 {
lab=D1}
N 3230 -380 3370 -380 {
lab=D0}
N 3370 -380 3380 -380 {
lab=D0}
N 3010 -330 3030 -330 {
lab=OUT01}
N 2870 -330 3010 -330 {
lab=OUT01}
N 2990 -510 3010 -510 {
lab=P02}
N 2990 -490 3010 -490 {
lab=LD0}
N 2990 -470 3010 -470 {
lab=Q01}
N 2990 -450 3010 -450 {
lab=Q02}
N 2990 -430 3010 -430 {
lab=Q03}
N 2990 -390 3010 -390 {
lab=Q05}
N 2990 -370 3010 -370 {
lab=Q06}
N 3010 -510 3030 -510 {
lab=P02}
N 3010 -490 3030 -490 {
lab=LD0}
N 3020 -470 3030 -470 {
lab=Q01}
N 3010 -450 3030 -450 {
lab=Q02}
N 3010 -430 3030 -430 {
lab=Q03}
N 3020 -410 3030 -410 {
lab=Q04}
N 3010 -390 3030 -390 {
lab=Q05}
N 3010 -370 3030 -370 {
lab=Q06}
N 3010 -350 3030 -350 {
lab=Q07}
N 2940 -510 2990 -510 {
lab=P02}
N 2920 -490 2990 -490 {
lab=LD0}
N 2900 -470 2990 -470 {
lab=Q01}
N 2880 -450 2990 -450 {
lab=Q02}
N 2860 -430 2990 -430 {
lab=Q03}
N 2840 -410 2990 -410 {
lab=Q04}
N 2820 -390 2990 -390 {
lab=Q05}
N 2800 -370 2990 -370 {
lab=Q06}
N 2780 -350 2990 -350 {
lab=Q07}
N 2990 -350 3010 -350 {
lab=Q07}
N 2990 -410 3010 -410 {
lab=Q04}
N 3010 -410 3020 -410 {
lab=Q04}
N 3010 -470 3020 -470 {
lab=Q01}
N 2770 -330 2870 -330 {
lab=OUT01}
N 3130 -600 3130 -560 {lab=VDD}
N 3130 -280 3130 -240 {lab=VSS}
N 3230 -360 3300 -360 {lab=IN_DIV}
N 3300 -360 3480 -360 {lab=IN_DIV}
N 2540 -330 2770 -330 {lab=OUT01}
N 2310 -830 2310 -530 {lab=FDIV}
N 2310 -330 2540 -330 {lab=OUT01}
N 2310 -430 2310 -330 {lab=OUT01}
N 2310 -480 2310 -430 {lab=OUT01}
N 1840 -800 1840 -760 {lab=VSS}
N 1840 -1140 1840 -1080 {lab=VDD}
N 1690 -980 1740 -980 {
lab=VSS}
N 1680 -960 1740 -960 {
lab=D10}
N 1660 -940 1740 -940 {
lab=D9}
N 1630 -920 1740 -920 {
lab=D8}
N 1600 -900 1740 -900 {
lab=D7}
N 1570 -880 1740 -880 {
lab=F_IN}
N 1590 -900 1600 -900 {
lab=D7}
N 1740 -1020 1740 -1000 {
lab=VSS}
N 1690 -1010 1690 -980 {
lab=VSS}
N 1690 -1010 1740 -1010 {
lab=VSS}
N 1500 -880 1570 -880 {lab=F_IN}
N 1960 -850 2160 -850 {
lab=pre_out}
N 1940 -850 1960 -850 {
lab=pre_out}
N 1940 -1030 1990 -1030 {
lab=P22}
N 1940 -1010 2010 -1010 {
lab=LD2}
N 1940 -990 2030 -990 {
lab=Q21}
N 1940 -970 2050 -970 {
lab=Q22}
N 1940 -950 2070 -950 {
lab=Q23}
N 1940 -930 2090 -930 {
lab=Q24}
N 1940 -910 2110 -910 {
lab=Q25}
N 1940 -890 2130 -890 {
lab=Q26}
N 1940 -870 2150 -870 {
lab=Q27}
N 4680 -600 4680 -560 {
lab=VDD}
N 4680 -280 4680 -270 {
lab=VSS}
N 4520 -440 4580 -440 {
lab=D19}
N 4500 -420 4580 -420 {
lab=D18}
N 4470 -400 4580 -400 {
lab=D17}
N 4440 -380 4580 -380 {
lab=D16}
N 4410 -360 4580 -360 {
lab=OUTB}
N 4780 -330 4800 -330 {
lab=#net1}
N 4430 -380 4440 -380 {
lab=D16}
N 4800 -330 4940 -330 {
lab=#net1}
N 5290 -440 5290 -400 {
lab=VDD}
N 5300 -250 5300 -220 {
lab=VSS}
N 4800 -510 4820 -510 {
lab=p2u}
N 4800 -490 4820 -490 {
lab=LD1u}
N 4800 -470 4820 -470 {
lab=Q11u}
N 4800 -450 4820 -450 {
lab=Q12u}
N 4800 -430 4820 -430 {
lab=Q13u}
N 4800 -390 4820 -390 {
lab=Q15u}
N 4800 -370 4820 -370 {
lab=Q16u}
N 4780 -510 4800 -510 {
lab=p2u}
N 4780 -490 4800 -490 {
lab=LD1u}
N 4780 -470 4790 -470 {
lab=Q11u}
N 4780 -450 4800 -450 {
lab=Q12u}
N 4780 -430 4800 -430 {
lab=Q13u}
N 4780 -410 4790 -410 {
lab=Q14u}
N 4780 -390 4800 -390 {
lab=Q15u}
N 4780 -370 4800 -370 {
lab=Q16u}
N 4780 -350 4800 -350 {
lab=Q17u}
N 4820 -510 4870 -510 {
lab=p2u}
N 4820 -490 4890 -490 {
lab=LD1u}
N 4820 -470 4910 -470 {
lab=Q11u}
N 4820 -450 4930 -450 {
lab=Q12u}
N 4820 -430 4950 -430 {
lab=Q13u}
N 4820 -410 4970 -410 {
lab=Q14u}
N 4820 -390 4990 -390 {
lab=Q15u}
N 4820 -370 5010 -370 {
lab=Q16u}
N 4820 -350 5030 -350 {
lab=Q17u}
N 4800 -350 4820 -350 {
lab=Q17u}
N 4800 -410 4820 -410 {
lab=Q14u}
N 4790 -410 4800 -410 {
lab=Q14u}
N 4790 -470 4800 -470 {
lab=Q11u}
N 4940 -330 5210 -330 {
lab=#net1}
N 4560 -500 4580 -500 {
lab=VSS}
N 4570 -480 4580 -480 {
lab=VSS}
N 4560 -460 4580 -460 {
lab=VSS}
N 5400 -330 5440 -330 {
lab=OUT_USB}
N 4560 -500 4560 -460 {
lab=VSS}
N 4560 -480 4570 -480 {
lab=VSS}
N 4500 -500 4560 -500 {
lab=VSS}
N 4680 -1080 4680 -1040 {
lab=VDD}
N 4680 -760 4680 -750 {
lab=VSS}
N 4520 -920 4580 -920 {
lab=D15}
N 4500 -900 4580 -900 {
lab=D14}
N 4470 -880 4580 -880 {
lab=D13}
N 4440 -860 4580 -860 {
lab=D12}
N 4410 -840 4580 -840 {
lab=OUT}
N 4780 -810 4800 -810 {
lab=OUT11}
N 4430 -860 4440 -860 {
lab=D12}
N 4800 -810 4940 -810 {
lab=OUT11}
N 5400 -810 5440 -810 {
lab=OUT_CORE}
N 5290 -920 5290 -880 {
lab=VDD}
N 5300 -730 5300 -700 {
lab=VSS}
N 4800 -990 4820 -990 {
lab=P12}
N 4800 -970 4820 -970 {
lab=LD1}
N 4800 -950 4820 -950 {
lab=Q11}
N 4800 -930 4820 -930 {
lab=Q12}
N 4800 -910 4820 -910 {
lab=Q13}
N 4800 -870 4820 -870 {
lab=Q15}
N 4800 -850 4820 -850 {
lab=Q16}
N 4780 -990 4800 -990 {
lab=P12}
N 4780 -970 4800 -970 {
lab=LD1}
N 4780 -950 4790 -950 {
lab=Q11}
N 4780 -930 4800 -930 {
lab=Q12}
N 4780 -910 4800 -910 {
lab=Q13}
N 4780 -890 4790 -890 {
lab=Q14}
N 4780 -870 4800 -870 {
lab=Q15}
N 4780 -850 4800 -850 {
lab=Q16}
N 4780 -830 4800 -830 {
lab=Q17}
N 4820 -990 4870 -990 {
lab=P12}
N 4820 -970 4890 -970 {
lab=LD1}
N 4820 -950 4910 -950 {
lab=Q11}
N 4820 -930 4930 -930 {
lab=Q12}
N 4820 -910 4950 -910 {
lab=Q13}
N 4820 -890 4970 -890 {
lab=Q14}
N 4820 -870 4990 -870 {
lab=Q15}
N 4820 -850 5010 -850 {
lab=Q16}
N 4820 -830 5030 -830 {
lab=Q17}
N 4800 -830 4820 -830 {
lab=Q17}
N 4800 -890 4820 -890 {
lab=Q14}
N 4790 -890 4800 -890 {
lab=Q14}
N 4790 -950 4800 -950 {
lab=Q11}
N 4940 -810 5210 -810 {
lab=OUT11}
N 4550 -960 4580 -960 {
lab=VSS}
N 4550 -940 4580 -940 {
lab=VSS}
N 4550 -980 4580 -980 {
lab=VSS}
N 780 -260 810 -260 {
lab=F_IN}
N 770 -260 780 -260 {
lab=F_IN}
N 770 -240 810 -240 {
lab=S1}
N 700 -280 810 -280 {lab=pre_out}
N 1110 -260 1180 -260 {lab=FIN}
N 960 -390 960 -370 {lab=VSS}
N 770 -460 810 -460 {
lab=UP1}
N 780 -440 810 -440 {
lab=UP_INPUT}
N 770 -440 780 -440 {
lab=UP_INPUT}
N 770 -420 810 -420 {
lab=S2}
N 700 -460 770 -460 {
lab=UP1}
N 690 -460 700 -460 {lab=UP1}
N 680 -280 700 -280 {lab=pre_out}
N 680 -460 690 -460 {lab=UP1}
N 1110 -440 1180 -440 {lab=UP}
N 790 -640 810 -640 {
lab=DN1}
N 800 -620 810 -620 {
lab=DN_INPUT}
N 790 -600 810 -600 {
lab=S3}
N 730 -640 790 -640 {
lab=DN1}
N 780 -620 800 -620 {
lab=DN_INPUT}
N 680 -640 730 -640 {lab=DN1}
N 1110 -620 1180 -620 {lab=DN}
N 960 -330 960 -310 {lab=VDD}
N 940 -330 960 -330 {lab=VDD}
N 960 -210 960 -190 {lab=VSS}
N 940 -190 960 -190 {lab=VSS}
N 940 -370 960 -370 {lab=VSS}
N 960 -510 960 -490 {lab=VDD}
N 940 -510 960 -510 {lab=VDD}
N 960 -690 960 -670 {lab=VDD}
N 940 -690 960 -690 {lab=VDD}
N 960 -570 960 -550 {lab=VSS}
N 940 -550 960 -550 {lab=VSS}
N 960 -750 960 -730 {lab=VSS}
N 940 -730 960 -730 {lab=VSS}
N 960 -870 960 -850 {lab=VDD}
N 940 -870 960 -870 {lab=VDD}
N 730 -820 800 -820 {
lab=MUFTA2}
N 800 -820 810 -820 {
lab=MUFTA2}
N 790 -800 810 -800 {
lab=VCTRL_IN}
N 790 -780 810 -780 {lab=S4}
N 780 -800 790 -800 {lab=VCTRL_IN}
N 680 -820 730 -820 {lab=MUFTA2}
N 1110 -800 1180 -800 {lab=VCTRL_OBV}
N 3540 -830 3570 -830 {lab=VCTRL_OBV}
N 1110 -980 1180 -980 {lab=MUFTA2}
N 780 -1000 810 -1000 {
lab=MUFTA}
N 790 -960 810 -960 {lab=S5}
N 780 -980 810 -980 {lab=LF_OFFCHIP}
N 680 -1000 780 -1000 {lab=MUFTA}
N 960 -930 960 -910 {lab=VSS}
N 940 -910 960 -910 {lab=VSS}
N 960 -1050 960 -1030 {lab=VDD}
N 940 -1050 960 -1050 {lab=VDD}
N 3110 -830 3130 -830 {lab=MUFTA2}
N 3130 -830 3160 -830 {lab=MUFTA2}
N 3160 -830 3190 -830 {lab=MUFTA2}
N 960 -1110 960 -1100 {lab=VSS}
N 960 -1100 960 -1090 {lab=VSS}
N 940 -1090 960 -1090 {lab=VSS}
N 960 -1230 960 -1210 {lab=VDD}
N 940 -1230 960 -1230 {lab=VDD}
N 780 -1180 810 -1180 {
lab=OUT_D}
N 790 -1140 810 -1140 {lab=S6}
N 780 -1160 810 -1160 {lab=F_IN}
N 680 -1180 780 -1180 {lab=OUT_D}
N 1110 -1160 1180 -1160 {lab=IN_DIV}
N 3640 -360 3700 -360 {lab=OUT_D}
N 960 -1280 960 -1260 {lab=VSS}
N 940 -1260 960 -1260 {lab=VSS}
N 960 -1400 960 -1380 {lab=VDD}
N 940 -1400 960 -1400 {lab=VDD}
N 770 -1350 810 -1350 {
lab=OUT01}
N 790 -1310 810 -1310 {lab=S7}
N 780 -1330 810 -1330 {lab=VSS}
N 680 -1350 770 -1350 {lab=OUT01}
N 1110 -1330 1180 -1330 {lab=FDIV}
N 1440 -1510 1480 -1510 {lab=pre_out}
N 1670 -1510 1710 -1510 {lab=PRE_SCALAR}
N 1570 -1430 1570 -1410 {lab=VSS}
N 1560 -1600 1560 -1580 {lab=VDD}
N 1870 -1510 1910 -1510 {lab=UP}
N 2000 -1430 2000 -1410 {lab=VSS}
N 1990 -1600 1990 -1580 {lab=VDD}
N 2100 -1510 2140 -1510 {lab=UP_OUT}
N 2260 -1510 2300 -1510 {lab=DN}
N 2390 -1430 2390 -1410 {lab=VSS}
N 2380 -1600 2380 -1580 {lab=VDD}
N 2490 -1510 2530 -1510 {lab=DN_OUT}
N 3980 -360 4070 -360 {lab=OUTA2}
N 4070 -360 4110 -360 {lab=OUTA2}
N 4200 -280 4200 -260 {lab=VSS}
N 4190 -450 4190 -430 {lab=VDD}
N 4300 -360 4340 -360 {lab=OUTB}
N 4340 -360 4410 -360 {lab=OUTB}
N 4200 -760 4200 -740 {lab=VSS}
N 4190 -930 4190 -910 {lab=VDD}
N 4300 -840 4340 -840 {lab=OUT}
N 3980 -840 4110 -840 {lab=OUTA1}
N 4340 -840 4410 -840 {lab=OUT}
N 4550 -960 4550 -940 {lab=VSS}
N 4550 -980 4550 -960 {lab=VSS}
N 4510 -980 4550 -980 {lab=VSS}
N 2700 -1510 2740 -1510 {lab=OUT01}
N 2830 -1430 2830 -1410 {lab=VSS}
N 2820 -1600 2820 -1580 {lab=VDD}
N 2930 -1510 2970 -1510 {lab=DIV_OUT}
C {VCO_1.sym} 3720 -820 0 0 {name=x7}
C {CP.sym} 2960 -810 0 0 {name=x8}
C {Current_Mirror_Top_s.sym} 2990 -1160 1 0 {name=x11}
C {devices/lab_wire.sym} 3080 -1160 2 0 {name=p121 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3720 -950 2 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -940 0 0 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2960 -700 0 0 {name=p25 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3720 -710 0 0 {name=p3 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2880 -1160 2 0 {name=p4 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3000 -920 2 0 {name=p176 sig_type=std_logic lab=ITAIL_SRC}
C {devices/lab_wire.sym} 2980 -980 0 0 {name=p177 sig_type=std_logic lab=ITAIL_SINK}
C {devices/lab_wire.sym} 3570 -770 2 0 {name=p5 sig_type=std_logic lab=VDD}
C {PFD.sym} 2520 -840 0 0 {name=x1}
C {devices/lab_wire.sym} 2520 -920 0 0 {name=p6 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -750 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/cap_mim_m3_2.sym} 3410 -730 0 0 {name=C3 model=cap_mim_m3_1 W=30 L=30 MF=44 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 3230 -710 0 0 {name=C4 model=cap_mim_m3_1 W=10 L=10 MF=50 spiceprefix=X}
C {sky130_fd_pr/res_high_po_0p69.sym} 3410 -790 0 0 {name=R1
L=110
model=res_high_po_0p69
spiceprefix=X
mult=1}
C {devices/lab_wire.sym} 3330 -650 0 0 {name=p18 sig_type=std_logic lab=VSS}
C {Tappered-Buffer_1.sym} 4130 -340 0 1 {name=x22}
C {devices/lab_wire.sym} 3810 -480 2 0 {name=p72 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3800 -230 2 0 {name=p43 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3640 -360 0 0 {name=p126 sig_type=std_logic lab=OUT_D}
C {devices/lab_wire.sym} 3250 -500 0 1 {name=p73 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} 3270 -480 0 1 {name=p74 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} 3280 -460 0 1 {name=p75 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} 3290 -440 0 1 {name=p76 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} 3310 -420 0 1 {name=p77 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} 3340 -400 0 1 {name=p78 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} 3380 -380 0 1 {name=p79 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} 2940 -510 2 1 {name=p145 sig_type=std_logic lab=P02}
C {devices/lab_pin.sym} 2920 -490 2 1 {name=p149 sig_type=std_logic lab=LD0}
C {devices/lab_pin.sym} 2910 -470 2 1 {name=p168 sig_type=std_logic lab=Q01}
C {devices/lab_pin.sym} 2890 -450 2 1 {name=p169 sig_type=std_logic lab=Q02}
C {devices/lab_pin.sym} 2860 -430 2 1 {name=p170 sig_type=std_logic lab=Q03}
C {devices/lab_pin.sym} 2850 -410 2 1 {name=p171 sig_type=std_logic lab=Q04}
C {devices/lab_pin.sym} 2820 -390 2 1 {name=p172 sig_type=std_logic lab=Q05}
C {devices/lab_pin.sym} 2810 -370 2 1 {name=p173 sig_type=std_logic lab=Q06}
C {devices/lab_pin.sym} 2780 -350 2 1 {name=p174 sig_type=std_logic lab=Q07}
C {devices/lab_pin.sym} 2310 -480 2 1 {name=p175 sig_type=std_logic lab=OUT01}
C {7b_divider.sym} 3080 -420 0 1 {name=x23}
C {devices/lab_wire.sym} 3130 -250 2 0 {name=p8 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3130 -590 2 0 {name=p9 sig_type=std_logic lab=VDD}
C {7b_divider.sym} 1890 -940 0 0 {name=x15}
C {devices/lab_wire.sym} 1840 -1110 0 0 {name=p10 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1840 -770 0 0 {name=p11 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1500 -880 0 0 {name=p12 sig_type=std_logic lab=F_IN}
C {devices/lab_pin.sym} 1680 -960 0 0 {name=p113 sig_type=std_logic lab=D10}
C {devices/lab_pin.sym} 1660 -940 0 0 {name=p114 sig_type=std_logic lab=D9}
C {devices/lab_pin.sym} 1630 -920 0 0 {name=p115 sig_type=std_logic lab=D8}
C {devices/lab_pin.sym} 1590 -900 0 0 {name=p116 sig_type=std_logic lab=D7}
C {devices/lab_wire.sym} 1740 -1020 0 0 {name=p111 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1990 -1030 2 0 {name=p83 sig_type=std_logic lab=P22}
C {devices/lab_pin.sym} 2010 -1010 2 0 {name=p84 sig_type=std_logic lab=LD2}
C {devices/lab_pin.sym} 2020 -990 2 0 {name=p85 sig_type=std_logic lab=Q21}
C {devices/lab_pin.sym} 2040 -970 2 0 {name=p86 sig_type=std_logic lab=Q22}
C {devices/lab_pin.sym} 2070 -950 2 0 {name=p87 sig_type=std_logic lab=Q23}
C {devices/lab_pin.sym} 2080 -930 2 0 {name=p88 sig_type=std_logic lab=Q24}
C {devices/lab_pin.sym} 2110 -910 2 0 {name=p92 sig_type=std_logic lab=Q25}
C {devices/lab_pin.sym} 2120 -890 2 0 {name=p118 sig_type=std_logic lab=Q26}
C {devices/lab_pin.sym} 2150 -870 2 0 {name=p119 sig_type=std_logic lab=Q27}
C {devices/lab_pin.sym} 2160 -850 2 0 {name=p182 sig_type=std_logic lab=pre_out}
C {devices/lab_pin.sym} 4520 -440 0 0 {name=p161 sig_type=std_logic lab=D19}
C {devices/lab_pin.sym} 4500 -420 0 0 {name=p185 sig_type=std_logic lab=D18}
C {devices/lab_pin.sym} 4470 -400 0 0 {name=p186 sig_type=std_logic lab=D17}
C {devices/lab_pin.sym} 4430 -380 0 0 {name=p187 sig_type=std_logic lab=D16}
C {devices/lab_wire.sym} 4680 -600 0 0 {name=p189 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4680 -270 2 0 {name=p190 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5290 -440 0 0 {name=p191 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4870 -510 2 0 {name=p194 sig_type=std_logic lab=p2u}
C {devices/lab_pin.sym} 4890 -490 2 0 {name=p195 sig_type=std_logic lab=LD1u}
C {devices/lab_pin.sym} 4900 -470 2 0 {name=p196 sig_type=std_logic lab=Q11u}
C {devices/lab_pin.sym} 4920 -450 2 0 {name=p197 sig_type=std_logic lab=Q12u}
C {devices/lab_pin.sym} 4950 -430 2 0 {name=p198 sig_type=std_logic lab=Q13u}
C {devices/lab_pin.sym} 4960 -410 2 0 {name=p199 sig_type=std_logic lab=Q14u}
C {devices/lab_pin.sym} 4990 -390 2 0 {name=p200 sig_type=std_logic lab=Q15u}
C {devices/lab_pin.sym} 5000 -370 2 0 {name=p201 sig_type=std_logic lab=Q16u}
C {devices/lab_pin.sym} 5030 -350 2 0 {name=p202 sig_type=std_logic lab=Q17u}
C {7b_divider.sym} 4730 -420 0 0 {name=x20}
C {Tappered-Buffer_1.sym} 4970 -310 0 0 {name=x19}
C {devices/lab_wire.sym} 5440 -330 2 0 {name=p204 sig_type=std_logic lab=OUT_USB}
C {devices/lab_wire.sym} 5300 -220 2 0 {name=p36 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4500 -500 0 0 {name=p42 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4520 -920 0 0 {name=p133 sig_type=std_logic lab=D15}
C {devices/lab_pin.sym} 4500 -900 0 0 {name=p134 sig_type=std_logic lab=D14}
C {devices/lab_pin.sym} 4470 -880 0 0 {name=p135 sig_type=std_logic lab=D13}
C {devices/lab_pin.sym} 4430 -860 0 0 {name=p136 sig_type=std_logic lab=D12}
C {devices/lab_pin.sym} 4320 -840 0 1 {name=p137 sig_type=std_logic lab=OUT}
C {devices/lab_wire.sym} 4680 -1080 0 0 {name=p147 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4680 -750 2 0 {name=p148 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5300 -700 2 0 {name=p151 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5290 -920 0 0 {name=p146 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4870 -990 2 0 {name=p129 sig_type=std_logic lab=P12}
C {devices/lab_pin.sym} 4890 -970 2 0 {name=p130 sig_type=std_logic lab=LD1}
C {devices/lab_pin.sym} 4900 -950 2 0 {name=p131 sig_type=std_logic lab=Q11}
C {devices/lab_pin.sym} 4920 -930 2 0 {name=p138 sig_type=std_logic lab=Q12}
C {devices/lab_pin.sym} 4950 -910 2 0 {name=p139 sig_type=std_logic lab=Q13}
C {devices/lab_pin.sym} 4960 -890 2 0 {name=p140 sig_type=std_logic lab=Q14}
C {devices/lab_pin.sym} 4990 -870 2 0 {name=p141 sig_type=std_logic lab=Q15}
C {devices/lab_pin.sym} 5000 -850 2 0 {name=p142 sig_type=std_logic lab=Q16}
C {devices/lab_pin.sym} 5030 -830 2 0 {name=p143 sig_type=std_logic lab=Q17}
C {devices/lab_pin.sym} 5150 -810 0 0 {name=p144 sig_type=std_logic lab=OUT11}
C {7b_divider.sym} 4730 -900 0 0 {name=x17}
C {Tappered-Buffer_1.sym} 4970 -790 0 0 {name=x18}
C {devices/lab_wire.sym} 5440 -810 2 0 {name=p150 sig_type=std_logic lab=OUT_CORE}
C {devices/lab_pin.sym} 4510 -980 0 0 {name=p82 sig_type=std_logic lab=VSS}
C {A_MUX.sym} 960 -260 0 0 {name=x5}
C {devices/lab_wire.sym} 770 -240 0 0 {name=p15 sig_type=std_logic lab=S1}
C {devices/lab_wire.sym} 770 -260 0 0 {name=p16 sig_type=std_logic lab=F_IN}
C {devices/lab_pin.sym} 680 -280 0 0 {name=p17 sig_type=std_logic lab=pre_out}
C {devices/lab_wire.sym} 1180 -260 2 0 {name=p59 sig_type=std_logic lab=FIN}
C {devices/lab_wire.sym} 2310 -850 0 1 {name=p19 sig_type=std_logic lab=FIN}
C {A_MUX.sym} 960 -440 0 0 {name=x6}
C {devices/lab_wire.sym} 770 -440 0 0 {name=p54 sig_type=std_logic lab=UP_INPUT}
C {devices/lab_wire.sym} 770 -420 0 0 {name=p55 sig_type=std_logic lab=S2}
C {devices/lab_wire.sym} 680 -460 0 0 {name=p180 sig_type=std_logic lab=UP1}
C {devices/lab_wire.sym} 1180 -440 2 0 {name=p160 sig_type=std_logic lab=UP}
C {devices/lab_wire.sym} 2760 -830 2 0 {name=p13 sig_type=std_logic lab=UP}
C {devices/lab_wire.sym} 2700 -850 0 1 {name=p23 sig_type=std_logic lab=UP1}
C {A_MUX.sym} 960 -620 0 0 {name=x9}
C {devices/lab_wire.sym} 790 -600 0 0 {name=p37 sig_type=std_logic lab=S3}
C {devices/lab_wire.sym} 780 -620 0 0 {name=p71 sig_type=std_logic lab=DN_INPUT}
C {devices/lab_wire.sym} 680 -640 0 0 {name=p181 sig_type=std_logic lab=DN1}
C {devices/lab_wire.sym} 1180 -620 2 0 {name=p49 sig_type=std_logic lab=DN}
C {devices/lab_wire.sym} 2760 -850 0 0 {name=p27 sig_type=std_logic lab=DN}
C {devices/lab_wire.sym} 2700 -830 2 0 {name=p28 sig_type=std_logic lab=DN1}
C {A_MUX.sym} 960 -800 0 0 {name=x10}
C {devices/lab_wire.sym} 940 -330 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 940 -190 0 0 {name=p20 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 940 -510 0 0 {name=p21 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 940 -370 0 0 {name=p22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 940 -690 0 0 {name=p24 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 940 -550 0 0 {name=p26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 940 -870 0 0 {name=p29 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 940 -730 0 0 {name=p30 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 780 -800 0 0 {name=p33 sig_type=std_logic lab=VCTRL_IN}
C {devices/lab_wire.sym} 790 -780 0 0 {name=p34 sig_type=std_logic lab=S4}
C {devices/lab_wire.sym} 680 -820 0 0 {name=p179 sig_type=std_logic lab=MUFTA2}
C {devices/lab_wire.sym} 1180 -800 2 0 {name=p81 sig_type=std_logic lab=VCTRL_OBV}
C {devices/lab_wire.sym} 3540 -830 0 0 {name=p31 sig_type=std_logic lab=VCTRL_OBV}
C {A_MUX.sym} 960 -980 0 0 {name=x12}
C {devices/lab_wire.sym} 1180 -980 2 0 {name=p32 sig_type=std_logic lab=MUFTA2}
C {devices/lab_wire.sym} 790 -960 0 0 {name=p63 sig_type=std_logic lab=S5}
C {devices/lab_wire.sym} 780 -980 0 0 {name=p64 sig_type=std_logic lab=LF_OFFCHIP}
C {devices/lab_wire.sym} 680 -1000 0 0 {name=p178 sig_type=std_logic lab=MUFTA}
C {devices/lab_wire.sym} 940 -1050 0 0 {name=p35 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 940 -910 0 0 {name=p38 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -830 0 0 {name=p39 sig_type=std_logic lab=MUFTA2}
C {devices/lab_wire.sym} 3330 -830 0 0 {name=p40 sig_type=std_logic lab=MUFTA}
C {devices/lab_wire.sym} 3020 -1360 0 0 {name=p41 sig_type=std_logic lab=ITAIL}
C {A_MUX.sym} 960 -1160 0 0 {name=x13}
C {devices/lab_wire.sym} 940 -1230 0 0 {name=p44 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 940 -1090 0 0 {name=p45 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 780 -1160 0 0 {name=p162 sig_type=std_logic lab=F_IN}
C {devices/lab_wire.sym} 680 -1180 0 0 {name=p46 sig_type=std_logic lab=OUT_D}
C {devices/lab_wire.sym} 790 -1140 0 0 {name=p47 sig_type=std_logic lab=S6}
C {devices/lab_pin.sym} 1180 -1160 2 0 {name=p165 sig_type=std_logic lab=IN_DIV}
C {devices/lab_pin.sym} 3480 -360 2 0 {name=p48 sig_type=std_logic lab=IN_DIV}
C {A_MUX.sym} 960 -1330 0 0 {name=x14}
C {devices/lab_wire.sym} 940 -1260 0 0 {name=p50 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 940 -1400 0 0 {name=p51 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 680 -1350 0 0 {name=p53 sig_type=std_logic lab=OUT01}
C {devices/lab_pin.sym} 780 -1330 2 1 {name=p56 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 790 -1310 0 0 {name=p52 sig_type=std_logic lab=S7}
C {devices/lab_wire.sym} 1180 -1330 2 0 {name=p60 sig_type=std_logic lab=FDIV}
C {devices/lab_wire.sym} 2310 -530 0 0 {name=p57 sig_type=std_logic lab=FDIV}
C {devices/ipin.sym} 410 -570 0 0 {name=p58 lab=S1}
C {devices/ipin.sym} 410 -720 0 0 {name=p61 lab=S6}
C {devices/ipin.sym} 410 -600 0 0 {name=p62 lab=S2}
C {devices/ipin.sym} 410 -630 0 0 {name=p65 lab=S3}
C {devices/ipin.sym} 410 -660 0 0 {name=p66 lab=S4}
C {devices/ipin.sym} 410 -690 0 0 {name=p67 lab=S5}
C {devices/ipin.sym} 410 -750 0 0 {name=p166 lab=S7}
C {Tappered-Buffer_1.sym} 1240 -1490 0 0 {name=x0}
C {devices/lab_pin.sym} 1440 -1510 0 0 {name=p68 sig_type=std_logic lab=pre_out}
C {devices/lab_pin.sym} 1710 -1510 2 0 {name=p110 sig_type=std_logic lab=PRE_SCALAR}
C {devices/lab_wire.sym} 1570 -1410 2 0 {name=p69 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1560 -1600 0 1 {name=p70 sig_type=std_logic lab=VDD}
C {Tappered-Buffer_1.sym} 1670 -1490 0 0 {name=x2}
C {devices/lab_wire.sym} 2000 -1410 2 0 {name=p80 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1990 -1600 0 1 {name=p89 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1870 -1510 0 0 {name=p90 sig_type=std_logic lab=UP}
C {devices/lab_wire.sym} 2140 -1510 0 1 {name=p91 sig_type=std_logic lab=UP_OUT}
C {Tappered-Buffer_1.sym} 2060 -1490 0 0 {name=x3}
C {devices/lab_wire.sym} 2390 -1410 2 0 {name=p93 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2380 -1600 0 1 {name=p94 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2530 -1510 2 0 {name=p155 sig_type=std_logic lab=DN_OUT}
C {devices/lab_wire.sym} 2260 -1510 0 0 {name=p95 sig_type=std_logic lab=DN}
C {Tappered-Buffer_1.sym} 3870 -340 0 0 {name=x21}
C {devices/lab_wire.sym} 4200 -260 2 0 {name=p96 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4190 -450 0 1 {name=p97 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4060 -360 0 0 {name=p184 sig_type=std_logic lab=OUTA2}
C {devices/lab_wire.sym} 4320 -360 0 1 {name=p98 sig_type=std_logic lab=OUTB}
C {Tappered-Buffer_1.sym} 3870 -820 0 0 {name=x16}
C {devices/lab_wire.sym} 4200 -740 2 0 {name=p99 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4190 -930 0 1 {name=p100 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4060 -840 0 0 {name=p183 sig_type=std_logic lab=OUTA1}
C {Tappered-Buffer_1.sym} 2500 -1490 0 0 {name=x4}
C {devices/lab_wire.sym} 2830 -1410 2 0 {name=p101 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2820 -1600 0 1 {name=p102 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2700 -1510 2 1 {name=p103 sig_type=std_logic lab=OUT01}
C {devices/lab_pin.sym} 2970 -1510 2 0 {name=p158 sig_type=std_logic lab=DIV_OUT}
C {devices/title.sym} 1680 0 0 0 {name=l1 author="ATIF KHAN"}
C {devices/ipin.sym} 150 -790 0 0 {name=p104 lab=D0}
C {devices/ipin.sym} 150 -760 0 0 {name=p105 lab=D1}
C {devices/ipin.sym} 150 -730 0 0 {name=p106 lab=D2}
C {devices/ipin.sym} 150 -700 0 0 {name=p107 lab=D3}
C {devices/ipin.sym} 150 -670 0 0 {name=p108 lab=D4}
C {devices/ipin.sym} 150 -640 0 0 {name=p109 lab=D5}
C {devices/ipin.sym} 150 -610 0 0 {name=p112 lab=D6}
C {devices/ipin.sym} 150 -580 0 0 {name=p117 lab=D7}
C {devices/ipin.sym} 150 -550 0 0 {name=p120 lab=D8}
C {devices/ipin.sym} 150 -520 0 0 {name=p122 lab=D9}
C {devices/ipin.sym} 280 -780 0 0 {name=p123 lab=D10}
C {devices/ipin.sym} 280 -750 0 0 {name=p124 lab=D12}
C {devices/ipin.sym} 280 -720 0 0 {name=p125 lab=D13}
C {devices/ipin.sym} 280 -690 0 0 {name=p127 lab=D14}
C {devices/ipin.sym} 280 -660 0 0 {name=p128 lab=D15}
C {devices/ipin.sym} 280 -630 0 0 {name=p132 lab=D16}
C {devices/ipin.sym} 280 -600 0 0 {name=p152 lab=D17}
C {devices/ipin.sym} 280 -570 0 0 {name=p153 lab=D18}
C {devices/ipin.sym} 280 -540 0 0 {name=p154 lab=D19}
C {devices/iopin.sym} 250 -1350 0 0 {name=p156 lab=VDD}
C {devices/iopin.sym} 250 -1320 0 0 {name=p157 lab=VSS}
C {devices/opin.sym} 3300 -1510 0 0 {name=p159 lab=PRE_SCALAR}
C {devices/ipin.sym} 300 -930 0 0 {name=p163 lab=F_IN}
C {devices/opin.sym} 3300 -1350 0 0 {name=p164 lab=DIV_OUT}
C {devices/ipin.sym} 300 -980 0 0 {name=p167 lab=UP_INPUT}
C {devices/ipin.sym} 300 -1030 0 0 {name=p188 lab=DN_INPUT}
C {devices/opin.sym} 3300 -1450 0 0 {name=p192 lab=UP_OUT}
C {devices/opin.sym} 3300 -1400 0 0 {name=p193 lab=DN_OUT}
C {devices/ipin.sym} 300 -1260 0 0 {name=p203 lab=ITAIL}
C {devices/opin.sym} 5700 -620 0 0 {name=p205 lab=OUT}
C {devices/iopin.sym} 5700 -570 0 0 {name=p206 lab=OUTB}
C {devices/ipin.sym} 300 -1080 0 0 {name=p207 lab=VCTRL_IN}
C {devices/ipin.sym} 300 -1130 0 0 {name=p208 lab=LF_OFFCHIP}
C {devices/opin.sym} 5700 -510 0 0 {name=p209 lab=OUT_USB}
C {devices/opin.sym} 5700 -670 0 0 {name=p210 lab=OUT_CORE}
